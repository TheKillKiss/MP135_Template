# IAR project MP135.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135D ST STM32MP135D
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32MP135Dxx; CORE_CA7; CACHE_USE; MMU_USE; DDR_TYPE_DDR3_4Gb
  ICCARM.CCIncludePath2: ..\User\Core\Inc; ..\Drivers\STM32MP13xx_HAL_Driver\Inc; ..\Drivers\STM32MP13xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\Include; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Core_A\Include; ..\Drivers\BSP\Inc; ..\Middleware\UCOS-III\CONFIG; ..\Middleware\UCOS-III\CPU; ..\Middleware\UCOS-III\LIB; ..\Middleware\UCOS-III\OS3; ..\Middleware\LwIP; ..\Middleware\LwIP\arch; ..\Middleware\LwIP\include; ..\User\Task\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MP135.bin
  ILINK.IlinkOutputFile: MP135.out
  ILINK.IlinkIcfFile: C:\Users\Kamisato\Desktop\folder\test\Drivers\CMSIS\Device\Source\IAR\linker\stm32mp13xx_a7_ddr.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/User/Core
    ../User/Core/Src/: eth.c lwip.c main.c stm32mp13xx_hal_msp.c stm32mp13xx_it.c
  group Application/User/Task
    ../User/Task/Src/: task_1ms.c
  group Drivers/BSP
    ../Drivers/BSP/Src/: bsp_led.c bsp_YT8531C.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../Drivers/CMSIS/Device/Source/: mmu_stm32mp13xx.c system_stm32mp13xx_A7_rtos.c
    ../Drivers/CMSIS/Device/Source/IAR/: startup_stm32mp135dxx_ca7_rtos.s
  group Drivers/HAL
    ../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_ddr.c stm32mp13xx_hal_eth.c stm32mp13xx_hal_eth_ex.c stm32mp13xx_hal_exti.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_mmc.c stm32mp13xx_hal_mmc_ex.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c stm32mp13xx_hal_uart.c stm32mp13xx_hal_uart_ex.c stm32mp13xx_ll_sdmmc.c
  group Middleware/LwIP
    ../Middleware/LwIP/: lwiperf.c
  group Middleware/LwIP/api
    ../Middleware/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middleware/LwIP/arch
    ../Middleware/LwIP/arch/: bpstruct.h cc.h epstruct.h ethernetif.c ethernetif.h lwipopts.h perf.h sys_arch.c sys_arch.h
  group Middleware/LwIP/core
    ../Middleware/LwIP/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middleware/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middleware/LwIP/netif
    ../Middleware/LwIP/netif/: ethernet.c
  group Middleware/UCOS-III/CONFIG
    ../Middleware/UCOS-III/CONFIG/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Middleware/UCOS-III/CPU
    ../Middleware/UCOS-III/CPU/: cpu.h cpu_a.asm cpu_c.c cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group Middleware/UCOS-III/LIB
    ../Middleware/UCOS-III/LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_str.c lib_str.h
  group Middleware/UCOS-III/OS3
    ../Middleware/UCOS-III/OS3/: os.h os_cfg_app.c os_core.c os_cpu.h os_cpu_a_vfp-d32.asm os_cpu_c.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
